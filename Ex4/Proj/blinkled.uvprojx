# Keil uVision project blinkled.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinkled
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Inc;..\Src;..\..\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\include;..\Proj;..\..\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\portable\MemMang;..\..\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../Src/: main.c
  group Inc
    ../Inc/: FreeRTOSConfig.h
  group FreeRTOS
    ../../FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c portmacro.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:RCC 3.5.0
